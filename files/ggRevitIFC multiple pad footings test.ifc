Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2013-09-10T21:28:44
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130709_2115(x64) - Exporter 3.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 10 21:28:44 2013 * Host: HPLaptop * Database: C:\Users\Jon\AppData\Local\Temp\{F53AC736-95EB-4A61-94D9-1AB6CFAD52D3}\ifc * Database version: 5507 * Database creation date: Tue Sep 10 21:28:39 2013 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 10 21:28:40 2013 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 10 21:28:40 2013 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -35, -16, -55, -342712; RefLongitude: 149, 7, 42, 908935; RefElevation: 0 mm
Other - Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no

# IfcFooting: MyFooting:MyFooting (4)
In: Level 1
Constraints - Moves With Grids: yes; Offset: 0 mm
Dimensions - Elevation at Bottom: -300 mm; Depth: 300 mm; Length: 2000 mm; Width: 2000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: yes; Rebar Cover - Bottom Face: Rebar Cover Settings: Rebar Cover 1; Rebar Cover - Other Faces: Rebar Cover Settings: Rebar Cover 1; Rebar Cover - Top Face: Rebar Cover Settings: Rebar Cover 1
Identity Data - OmniClass Number: 23.25.05.00; OmniClass Title: Foundations
Name (MyFooting:MyFooting:...) | Host | Level
150085 | Identity Data - Mark: F1
150099 | Level : Level 1 | Level: Level 1
150104 | Level : Level 1 | Level: Level 1
150109 | Level : Level 1 | Level: Level 1
