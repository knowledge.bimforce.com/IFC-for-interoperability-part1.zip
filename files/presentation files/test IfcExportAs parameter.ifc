Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2013-09-27T11:22:04
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 3.5.0.0 - Alternate UI 2.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 27 11:22:04 2013 * Host: MDR_LPTP_BTO * Database: C:\Users\Martijn\AppData\Local\Temp\{D81FBB8A-C4B5-4996-B3D5-42D1FDFD1AB3}\ifc * Database version: 5507 * Database creation date: Fri Sep 27 11:22:01 2013 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 27 11:22:01 2013 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 27 11:22:01 2013 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: E:\MdR Advies\Google Drive\001 - Overige werkzaamheden\RTC\RTC2013 Session 6 - IFC for Interoperability\files\presentation files\test IfcExportAs parameter.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: IFC test ceiling, IFC test ceiling1:IFC test ceiling:3193
In: Level 1
Pset_BuildingElementProxyCommon - Reference: IFC test ceiling

# IfcBuildingElementProxy: test GM IFC override, test GM IFC override1:test GM IFC override:3219
In: Level 1
Pset_BuildingElementProxyCommon - Reference: test GM IFC override

# IfcCovering: IFC test ceiling:IFC test ceiling, IFC test ceiling:IFC test ceiling:2372
In: Level 1
PredefinedType: CEILING
Pset_CoveringCommon - Reference: IFC test ceiling

# IfcEnergyConversionDevice: Type 1, test GM family without IfcExportAs:Type 1:3855
In: Level 1
Type - PredefinedType: AIRCOOLED
Pset_DistributionFlowElementCommon - Reference: Type 1

# IfcEnergyConversionDevice: test GM IFC override, test GM IFC override:test GM IFC override:2509
In: Level 1
Type - PredefinedType: AIRCOOLED
Pset_DistributionFlowElementCommon - Reference: test GM IFC override

# IfcRailing: test GM family:Type 1, test GM family:Type 1:3162
In: Level 1
Pset_RailingCommon - Reference: Type 1; IsExternal: no
